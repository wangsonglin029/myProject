# Keil uVision project Demo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: AC1003 Generic
  pack: AscendChip.AC1003.1.0.2
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Demo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\Objects\@L.bin !L
  c flags: uC99=1 wLevel=2
  c include: ..\USER\inc;..\DEVICE\Keil;..\DEVICE;..\FWLB\inc;..\SH367309\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group DEVICE
    ../DEVICE/: system_ac1003.c
    ../DEVICE/Keil/: startup_ac1003.s
  group FWLB
    ../FWLB/src/: ac1003_adc.c ac1003_advtim.c ac1003_awk.c ac1003_beeper.c ac1003_clktrim.c ac1003_crc.c ac1003_debug.c ac1003_delay.c ac1003_exti.c ac1003_flash.c ac1003_gpio.c ac1003_i2c.c ac1003_it.c ac1003_iwdt.c ac1003_lptimer.c ac1003_lpuart.c ac1003_lvd.c ac1003_owire.c ac1003_pca.c ac1003_rcc.c ac1003_rtc.c ac1003_spi.c ac1003_syscon.c ac1003_timer.c ac1003_uart.c ac1003_vc.c ac1003_wwdt.c misc.c
  group USER
    ../USER/src/: main.c test_uart.c test_i2c_master.c config.c kalman.c mgpio.c sf.c test_adc.c test_basetime.c test_exti.c test_flash.c test_iwdt .c test_wwdt.c
    ../SH367309/src/: sh367309.c
  group DOC
    ../DOC/: readme.txt
software components: CMSIS:CORE 5.3.0

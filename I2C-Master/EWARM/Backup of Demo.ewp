# IAR project Backup of Demo.ewp, settings and files
configuration Target 1 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ./../USER/inc; ../../../FWLB/inc; ../../../DEVICE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Ascendchip\AC1003AI6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group DEVICE
    ../../../DEVICE/IAR/: startup_ac1003.s
    ../../../DEVICE/: system_ac1003.c
  group DOC
    ../DOC/: readme.txt
  group FWLB
    ../../../FWLB/src/: ac1003_adc.c ac1003_advtim.c ac1003_awk.c ac1003_beeper.c ac1003_clktrim.c ac1003_crc.c ac1003_debug.c ac1003_delay.c ac1003_exti.c ac1003_flash.c ac1003_gpio.c ac1003_i2c.c ac1003_it.c ac1003_iwdt.c ac1003_lptimer.c ac1003_lpuart.c ac1003_lvd.c ac1003_owire.c ac1003_pca.c ac1003_rcc.c ac1003_rtc.c ac1003_spi.c ac1003_syscon.c ac1003_timer.c ac1003_uart.c ac1003_vc.c ac1003_wwdt.c misc.c
  group USER
    ../USER/src/: main.c test_i2c_master.c test_uart.c
